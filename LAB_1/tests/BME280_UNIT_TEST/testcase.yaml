## LAB_1/tests/BME280_UNIT_TEST/testcase.yaml
```yaml
tests:
  bme280.raw:
    platform_allow:
      - qemu_cortex_m3
    tags:
      - bme280
      - i2c
      - unit
    harness: ztest
    
```
